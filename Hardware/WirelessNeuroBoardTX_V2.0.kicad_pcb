# Repository juseus03/--WNB--WirelessNBHardware

File README.md:

# WirelessNBHardware
Hardware explanation and code for WNB.

This is the code for programming the WNB developed as my undergraduate final project, this projects are write in C and should be opened in AtmelStudio. Also there is all the circuit board developed in kiCad.
There are three projects:

-"Blinking led Tarjeta:" This is the first project you should mount to the board, it makes the two LED flicker and that means everithing is well connected on the board.

-"Firmware_TransmisorEEG_BT:" This program the board to transmit the data for the 8 channels, whit this configurations:

--CH1: Test Mode
--CH2: Test Mode
--CH3: Normal Mode
--CH4: Normal Mode
--CH5: Normal Mode
--CH6: Normal Mode
--CH7: Short circuit Mode
--CH8: Short circuit Mode

--Bluetooth data is transmited at a baudrate of 230400Bd and 250msp.

-"Hardware:" This contains all the files for making the board PCB, it contains some minor mistakes that have been found in the develop of this project, but is the version of the board that had been proved.

## KiCad design Hardware/WirelessNeuroBoardTX_V2.0.kicad_pcb

Parts:
AVCC39_C1: 100n; C_0805_HandSoldering
AVCC_C1: 10u; C_1206_HandSoldering
AVDD21_C1, AVDD59_C1: 1u; C_1206_HandSoldering
AVDD21_C2, AVDD59_C2: 100n; C_0805_HandSoldering
BIAS_SELECT1: SWITCH_INV; Pin_Header_Straight_1x02
BTCON_LED1: VERDE; LED-0805
BTCON_LED_R1: 1k; R_1206_HandSoldering
BT_AVCC_C1: 10u; C_1206_HandSoldering
Bat_con1: CONN_2; Molex_78171-0002
Bead1: INDUCTOR; Neosid_Inductor_SM-NE45_SMD1812
C_BIAS1: 10n; C_0805_HandSoldering
CinMax884: 100n; C_0805_HandSoldering
CoutMax884: 2.2u; C_0603_HandSoldering
DVDD48_C1: 1u; C_1206_HandSoldering
DVDD48_C2: 100n; C_0805_HandSoldering
DigitalPort1: CONN_5; Molex_78171-0005
ELECT_3: CONN_2; Molex_53780_0270
ELEC_1, ELEC_2: CONN_8; Molex_53780_0870
EL_R1_N1, EL_R1_P1, EL_R2_N1, EL_R2_P1, EL_R3_N1, EL_R3_P1, EL_R4_N1, EL_R4_P1, EL_R5_N1, EL_R5_P1, EL_R6_N1, EL_R6_P1, EL_R7_N1, EL_R7_P1, EL_R8_N1, EL_R8_P1: 4.99k; R_1206_HandSoldering
EL_RBIAS1: 4.99k; R_1206_HandSoldering
Inicie_R1: 10k; R_1206_HandSoldering
MAX_C4: 10n; C_0805_HandSoldering
MAX_R1: 10k; R_1206_HandSoldering
MAX_R2: 1.5k; R_1206_HandSoldering
MAX_R3: 1k; R_1206_HandSoldering
OK_LED1: ROJO; LED-0805
OK_LED_R1: 1k; R_1206_HandSoldering
PDI_R1: 10k; R_1206_HandSoldering
Prog_Con1: CONN_4; Molex_78171-0004
RBIAS1: 159k; R_0805_HandSoldering
REF_C1, REF_C2: 1u; C_1206_HandSoldering
REF_R1, REF_R2: 2M; R_1206_HandSoldering
SW1: SW_PUSH; SW_SPST_EVQQ2
U1, U10: OPA376; SOT-23-5
U2: KC21Bluetooth; K21Bluetooth
U9: ADS1298; TQFP-64_10x10mm_Pitch0.5mm
U11: ATXMEGA128A4U; TQFP-44_10x10mm_Pitch0.8mm
U13: MAX884; SOIC-8_3.9x4.9mm_Pitch1.27mm
VCAP1_C1: 22u; C_1206_HandSoldering
VCAP2_C1, VCAP3_55_C1, VCAP4_C1: 1u; C_1206_HandSoldering
VCAP3_55_C2: 100n; C_0805_HandSoldering
VCC9_C1: 100n; C_0805
VCC19_C1, VCC31_C1: 100n; C_0805_HandSoldering
VREF_C1: 10u; C_1206_HandSoldering
VREF_C2: 100n; C_0805_HandSoldering

Connections:
+3.3V: AVDD21_C1.1, AVDD21_C2.1, AVDD59_C1.1, AVDD59_C2.1, BT_AVCC_C1.1, Bead1.1, CoutMax884.1, DVDD48_C1.2, DVDD48_C2.2, Inicie_R1.2, MAX_R1.1, PDI_R1.1, Prog_Con1.1, REF_C1.1, REF_C2.1, REF_R2.1, U1.5 (V+), U2.24, U9.19, U9.21, U9.22, U9.48, U9.50, U9.52, U9.54, U9.56, U9.59, U10.5 (V+), U11.9 (VCC), U11.19 (VDD), U11.31 (VCC), U13.4 (OUT), VCC9_C1.1, VCC19_C1.1, VCC31_C1.2
+8V: Bat_con1.1, CinMax884.1, MAX_R2.2, U13.5 (IN), U13.7 (OFF)
/AD_CLK: U9.37, U11.28 (PE0)
/AD_CS_: U9.39, U11.14 (PC4)
/AD_DIN_MOSI: U9.34, U11.17 (PC7)
/AD_DOUT_MISO: U9.43, U11.16 (PC6)
/AD_DRDY_: U9.47, U11.25 (PD5)
/AD_IN_1N: EL_R1_N1.2, U9.15
/AD_IN_1P: EL_R1_P1.2, U9.16
/AD_IN_2N: EL_R2_N1.2, U9.13
/AD_IN_2P: EL_R2_P1.2, U9.14
/AD_IN_3N: EL_R3_N1.2, U9.11
/AD_IN_3P: EL_R3_P1.2, U9.12
/AD_IN_4N: EL_R4_N1.1, U9.9
/AD_IN_4P: EL_R4_P1.2, U9.10
/AD_IN_5N: EL_R5_N1.1, U9.7
/AD_IN_5P: EL_R5_P1.1, U9.8
/AD_IN_6N: EL_R6_N1.1, U9.5
/AD_IN_6P: EL_R6_P1.1, U9.6
/AD_IN_7N: EL_R7_N1.1, U9.3
/AD_IN_7P: EL_R7_P1.1, U9.4
/AD_IN_8N: EL_R8_N1.1, U9.1
/AD_IN_8P: EL_R8_P1.1, U9.2
/AD_PWD_: U9.35, U11.23 (PD3)
/AD_RESET_: U9.36, U11.24 (PD4)
/AD_SCK: U9.40, U11.15 (PC5)
/AD_START: U9.38, U11.22 (PD2)
/AVCC: AVCC39_C1.2, AVCC_C1.1, Bead1.2, U11.39 (AVCC)
/BIAS_ELEC: BIAS_SELECT1.2, EL_RBIAS1.2
/BIAS_MID: BIAS_SELECT1.1, U10.1 (OUT), U10.4 (-IN)
/BTCON_LED: BTCON_LED1.1 (A), U11.5 (PB1)
/BT_RX: U2.8, U11.13 (PC3)
/BT_TX: U2.6, U11.12 (PC2)
/Inicie_OP: Inicie_R1.1, SW1.1, U11.6 (PB2)
/LB_Ind: MAX_R1.2, U11.7 (PB3), U13.1 (LBO)
/OK_LED: OK_LED1.1 (A), U11.4 (PB0)
/PDI_CLK: PDI_R1.2, Prog_Con1.2, U11.35 (RESET)
/PDI_DATA: Prog_Con1.3, U11.34 (PDI)
/PORTA0: DigitalPort1.4, U11.40 (PA0)
/PORTA1: DigitalPort1.3, U11.41 (PA1)
/PORTA2: DigitalPort1.2, U11.42 (PA2)
/PORTA3: DigitalPort1.1, U11.43 (PA3)
/RLDINV: C_BIAS1.2, RBIAS1.1, U9.61
/RLDOUT: BIAS_SELECT1.3, C_BIAS1.1, RBIAS1.2, U9.62, U9.63
/TASTN_PACE_OUT2: U1.3 (+IN), U9.18
/TASTP_PACE_OUT1: U1.1 (OUT), U1.4 (-IN), U9.17
GND: AVCC39_C1.1, AVCC_C1.2, AVDD21_C1.2, AVDD21_C2.2, AVDD59_C1.2, AVDD59_C2.2, BTCON_LED_R1.2, BT_AVCC_C1.2, Bat_con1.2 (PM), CinMax884.2, CoutMax884.2, DVDD48_C1.1, DVDD48_C2.1, DigitalPort1.5, MAX_C4.2, MAX_R3.1, OK_LED_R1.2, Prog_Con1.4, REF_C1.2, REF_C2.2, REF_R1.2, SW1.2, U1.2 (V-), U2.23, U9.20, U9.23, U9.25, U9.31, U9.32, U9.33, U9.41, U9.42, U9.44, U9.45, U9.46, U9.49, U9.51, U9.53, U9.57, U9.58, U10.2 (V-), U11.1 (PA5), U11.2 (PA6), U11.3 (PA7), U11.8 (GND), U11.18 (GND), U11.26 (PD6), U11.27 (PD7), U11.29 (PE1), U11.30 (GND), U11.32 (PE2), U11.33 (PE3), U11.38 (GND), U11.44 (PA4), U13.2 (SET), U13.3 (GND), U13.6 (GND), VCAP1_C1.2, VCAP2_C1.2, VCAP3_55_C1.2, VCAP3_55_C2.2, VCAP4_C1.2, VCC9_C1.2, VCC19_C1.2, VCC31_C1.1, VREF_C1.2, VREF_C2.2
unnamed: BTCON_LED1.2 (K), BTCON_LED_R1.1
unnamed: ELECT_3.1, EL_RBIAS1.1
unnamed: ELEC_1.1, EL_R4_N1.2
unnamed: ELEC_1.2, EL_R4_P1.1
unnamed: ELEC_1.3, EL_R3_N1.1
unnamed: ELEC_1.4, EL_R3_P1.1
unnamed: ELEC_1.5, EL_R2_N1.1
unnamed: ELEC_1.6, EL_R2_P1.1
unnamed: ELEC_1.7, EL_R1_N1.1
unnamed: ELEC_1.8, EL_R1_P1.1
unnamed: ELEC_2.1, EL_R8_N1.2
unnamed: ELEC_2.2, EL_R8_P1.2
unnamed: ELEC_2.3, EL_R7_N1.2
unnamed: ELEC_2.4, EL_R7_P1.2
unnamed: ELEC_2.5, EL_R6_N1.2
unnamed: ELEC_2.6, EL_R6_P1.2
unnamed: ELEC_2.7, EL_R5_N1.2
unnamed: ELEC_2.8, EL_R5_P1.2
unnamed: MAX_C4.1, MAX_R2.1, MAX_R3.2, U13.8 (LBI)
unnamed: OK_LED1.2 (K), OK_LED_R1.1
unnamed: REF_R1.1, REF_R2.2, U10.3 (+IN)
unnamed: U9.24, VREF_C1.1, VREF_C2.1
unnamed: U9.26, VCAP4_C1.1
unnamed: U9.28, VCAP1_C1.1
unnamed: U9.30, VCAP2_C1.1
unnamed: U9.55, VCAP3_55_C1.1, VCAP3_55_C2.1

Notes on the sheet:
Para baterías recargables de 3.7V el VLBI es 3.0V
VLBI =1.2(R2+R3)/R3
Circuito de Referencia Variable
Circuito de polarización
Pulsador para iniciar operación
Filtro calculado para Fc = 100 Hz

Board: 2 copper layers, 49.5 x 49.5 mm, 69 parts (32 on the bottom side), 73 nets.

## Code that names these connections

File Firmware TransmisorEEG_BT/2013-04 TransmisorEEG/ADS1298.h:

/*
 * ADS1298.h
 *
 * Created: 31/01/2013 07:34:04 p.m.
 *  Author: Juan Manuel
 */ 

/* PINES UTILIZADOS Y EQUIVALENCIA
PUERTO C:
ADS1298		PIN			DIRECCIÓN
-------------------------------------
CS			PC4			OUT
SCK			PC5/XCK1	OUT
DOUT		PC6/MISO	IN
DIN			PC7/MOSI	OUT

PUERTO D:
ADS1298		PIN			DIRECCIÓN
-------------------------------------
START		PD2			OUT
PWD			PD3			OUT
RESET		PD4			OUT
DRDY		PD5			IN

PUERTO E:
ADS1298		PIN			DIRECCIÓN
-------------------------------------
CLK			PE0			IN

*/

#ifndef ADS1298_H_
#define ADS1298_H_

//Definición de pines
//Puerto C
#define PIN_ADS_CS_bm PIN4_bm
#define PIN_ADS_SCK_bm PIN5_bm
#define PIN_ADS_DOUT_bm PIN6_bm
#define PIN_ADS_DIN_bm PIN7_bm

//Puerto D
#define PIN_ADS_START_bm PIN2_bm
#define PIN_ADS_PWD_bm PIN3_bm
#define PIN_ADS_RESET_bm PIN4_bm
#define PIN_ADS_DRDY_bm PIN5_bm

//Puerto E
#define PIN_ADS_CLK_bm PIN0_bm 

//Comandos
//Sistema
#define ADS_WAKEUP 0x02
#define ADS_STANDBY 0x04
#define ADS_RESET 0x06
#define ADS_START 0x08
#define ADS_STOP 0x0a
//Lectura de datos
#define ADS_RDATAC 0x10
#define ADS_SDATAC 0x11
#define ADS_RDATA 0x12
//Registros
#define ADS_RREG 0x20
#define ADS_WREG 0x40

//Direcciones de registros
//Global settings
#define ADS_REG_CONFIG1 0x01
#define ADS_REG_CONFIG2 0x02
#define ADS_REG_CONFIG3 0x03
#define ADS_REG_LOFF 0x04
//Channel specific settings
#define ADS_REG_CH1SET 0x05
#define ADS_REG_CH2SET 0x06
#define ADS_REG_CH3SET 0x07
#define ADS_REG_CH4SET 0x08
#define ADS_REG_CH5SET 0x09
#define ADS_REG_CH6SET 0x0a
#define ADS_REG_CH7SET 0x0b
#define ADS_REG_CH8SET 0x0c
#define ADS_REG_RLD_SENSP 0x0d
#define ADS_REG_RLD_SENSN 0x0e
#define ADS_REG_LOFF_SENSP 0x0f
#define ADS_REG_LOFF_SENSN 0x10
#define ADS_REG_LOFF_FLIP 0x11
//Lead-Off Status Registers (read only)
#define ADS_REG_LOFF_STATP 0x12
#define ADS_REG_LOFF_STATN 0x13
//Other
#define ADS_REG_GPIO 0x14
#define ADS_REG_PACE 0x15
#define ADS_REG_RESP 0x16
#define ADS_REG_CONFIG4 0x17
#define ADS_REG_WCT1 0x18
#define ADS_REG_WCT2 0x19

//Banderas
#define ADS_BYTE_ENVIADO_bm 0x01
#define ADS_ARREGLO_ENVIADO_bm 0x02
#define ADS_MUESTRA_RECIBIDA_bm 0x04
#define ADS_DETENGA_ADQUISICION_bm 0x08
#define ADS_ADQUISICION_DETENIDA_bm 0x10

//Modos de transmisión
#define ADS_MODO_COM_ENVIANDO_BYTE 1
#define ADS_MODO_COM_ENVIANDO_ARREGLO 2
#define ADS_MODO_COM_RECIBIENDO_MUESTRA 3

//Modos de configuración
#define ADS_MODO_CONFIG_CORTO 1
#define ADS_MODO_CONFIG_TEST 2
#define ADS_MODO_CONFIG_NORMAL 3
#define ADS_MODO_CONFIG_OFF 4
#define ADS_MODO_CONFIG_TEST_CH1 5
#define ADS_MODO_CONFIG_TEST_CH2 6
#define ADS_MODO_CONFIG_TEST_CH3 7
#define ADS_MODO_CONFIG_TEST_CH4 8
#define ADS_MODO_CONFIG_TEST_CH5 9
#define ADS_MODO_CONFIG_TEST_CH6 10
#define ADS_MODO_CONFIG_TEST_CH7 11
#define ADS_MODO_CONFIG_TEST_CH8 12 

//Modos de energía
#define ADS_ENERGIA_HIGHRESOLUTION 0x80
#define ADS_ENERGIA_LOWPOWER 0x00

//Data Rates
#define ADS_DATARATE_HR_32K 0x00
#define ADS_DATARATE_HR_16K 0x01
#define ADS_DATARATE_HR_8K 0x02
#define ADS_DATARATE_HR_4K 0x03
#define ADS_DATARATE_HR_2K 0x04
#define ADS_DATARATE_HR_1K 0x05
#define ADS_DATARATE_HR_500 0x06

#define ADS_DATARATE_LP_16K 0x00
#define ADS_DATARATE_LP_8K 0x01
#define ADS_DATARATE_LP_4K 0x02
#define ADS_DATARATE_LP_2K 0x03
#define ADS_DATARATE_LP_1K 0x04
#define ADS_DATARATE_LP_500 0x05
#define ADS_DATARATE_LP_250 0x06

//Ganancias
#define ADS_GANANCIA_1 0b00010000
#define ADS_GANANCIA_2 0b00100000
#define ADS_GANANCIA_3 0b00110000
#define ADS_GANANCIA_4 0b01000000
#define ADS_GANANCIA_6 0x00
#define ADS_GANANCIA_8 0b01010000
#define ADS_GANANCIA_12 0b01100000

//Mux Modo
#define ADS_MUX_NORMAL 0x00
#define ADS_MUX_CORTO 0b00000001
#define ADS_MUX_RLD 0b00000010
#define ADS_MUX_MVDD 0b00000011
#define ADS_MUX_TEMPER 0b00000100
#define ADS_MUX_TEST 0b00000101
#define ADS_MUX_DRP 0b00000110
#define ADS_MUX_DRN 0b00000111

#define ADS_CHN_OFF 0x80

//Constantes
#define ADS_ARREGLOMAX 17

//Estados
#define ADS_ESTADO_ESPEREDRDY 1
#define ADS_ESTADO_BUSQUECOLA 2
#define ADS_ESTADO_EMPIECE_ADQUISICION 3
#define ADS_ESTADO_ADQUIRIENDO 4

typedef struct
{
	char banderas; //banderas
	char modo_com; //Modo de comunicación
	char arreglo[ADS_ARREGLOMAX]; //Máximo tamaño del arreglo
	char n_datos; //Contador de datos
	char datos_max; //Máximo de datos a transmitir/recibir
	char dato; //dato leído, almacenamiento temporal
	char n_datos_leidos; //contador datos leídos
	char estado; //estado de máquina de estados
	char cola_activa; //cola activa para llenado
}ADS_Control;

void ADS_Init(volatile ADS_Control *ADS_Ctrl, 
				char powermode,
				char datarate);

void ADS_EnviarByte(volatile ADS_Control *ADS_Ctrl, 
				char comando);

void ADS_EnviarArreglo(volatile ADS_Control *ADS_Ctrl,
					char datos_max );

void ADS_ConfigChannels(volatile ADS_Control *ADS_Ctrl,
					char Config_modo,
					char Ganancia);
					
void ADS_Adquiera(volatile ADS_Control *ADS_Ctrl);

void ADS_BusqueColaLibre(volatile ADS_Control *ADS_Ctrl);

void ADS_Detenga(volatile ADS_Control *ADS_Ctrl);

					
					

#endif /* ADS1298_H_ */

## Commit log

2016-04-04 :boom::camel: Added .gitattributes & .gitignore files
2016-04-04 add blinking led
    Blinking led for WNB
2016-05-21 up everything
2016-05-21 Transfer data
    Haven't that data is good
